# Keil uVision project FreeRtos.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 电子系统综合设计 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10X_FWLib\inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\ADC;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\HARDWARE;..\HARDWARE\OLED;..\HARDWARE\MPU6050;..\HARDWARE\KEY;..\HARDWARE\LED;..\APP\inc;..\HARDWARE\BLUETOOTH;..\HARDWARE\ESP8266;..\EDP;..\NET_CONNET;..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/src/: menu.c
    ../../Slave/essd-stdlib+freeRTOS-v2.2/APP/src/: transfer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10X_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/: bsp.c
    ../HARDWARE/OLED/: GUISlim.c hdulogo.c SimSun_12.c ssd1306.c ssd1306_i2c.c
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c STM32_I2C.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ESP8266/: esp8266.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group EDP
    ../EDP/: EdpKit.c
  group Onenet
    ../NET_CONNET/: ONENETCONNET.c
